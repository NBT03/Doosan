Commit message: push_23/08

File: assets/ur5/base_doosan.urdf (robot description, URDF)
Before this commit: robot m0609, 2 links, 1 joints
Links:
- link base_0: geometry visual mesh filename=assets/ur5/m0609_collision/base_doosan.STL scale=0.01 0.01 0.01
